# Keil uVision project bp_pro.uvprojx, settings and files
target bp_ucgui_template_ucos (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bp_ucgui_template_ucos +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\application;..\bpdriver;..\stm32lib\inc;..\stm32lib\m3;..\stm32lib\src;..\bpdriver\ra8875;..\bpdriver\uip\uip;..\bpdriver\uip\app;..\bpdriver\uip\unix;..\bpdriver\tff;..\ucos\source;..\ucos\cpu;..\ucos\cfg;..\ucgui\Config;..\ucgui\Core;..\ucgui\Widget;..\ucgui\WM;..\ucgui\MultiLayer;..\ucgui\GUIDemo;..\ucos\GUI_X;..\ucgui\Font;..\ucgui\LCDDriver;..\ucgui\ConvertColor;..\ucgui\ConvertMono;..\ucgui\GUIDemo;..\ucgui\AntiAlias
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: stm32f10x_it.c main.c stm32f10x_conf.h bp_config.c startup_stm32f10x_hd.s usart.c CommonFunction.c UI2000.c PowerLineCarrier.c Flash.c RTC.c cal_test.c ADC.c Test0_10V.c CalOtherTest.c LCD12864.c GP9034T.c FlashOperate.c LoraC6000.c
  group bpdriver
    ../bpdriver/: include.h utility.c regtarge.c bptimer.c daad.c tft.c
  group stm32lib
    ../stm32lib/inc/: stm32f10x_wwdg.h misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
    ../stm32lib/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group stm32core
    ../stm32lib/m3/: system_stm32f10x.h core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c
  group ucos/source
    ../ucos/source/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group ucos/cpu
    ../ucos/cpu/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group ucos/cfg
    ../ucos/cfg/: os_cfg.h app_cfg.h
  group ucos/guix
    ../ucos/GUI_X/: GUI_X_uCOS.c GUI_X_Touch.c
